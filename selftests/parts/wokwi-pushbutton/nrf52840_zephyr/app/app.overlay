/ {
    aliases {
        my-button = &button_p1_11;
    };

    buttons {
        compatible = "gpio-keys";

        button_p1_11: button_p1_11 {
            gpios = <&gpio1 11 GPIO_ACTIVE_HIGH>;
            label = "User Button with External Pull-Down";
        };
    };
};
