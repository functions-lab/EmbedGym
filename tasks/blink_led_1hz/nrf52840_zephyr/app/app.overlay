/ {
    aliases {
        my-led = &led_p0_04;
    };

    leds {
        compatible = "gpio-leds";
        led_p0_04: led_p0_04 {
            gpios = <&gpio1 15 GPIO_ACTIVE_HIGH>;
        };
    };
};
