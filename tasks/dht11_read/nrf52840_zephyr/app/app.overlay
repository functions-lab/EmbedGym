/ {
    aliases {
        data-dht11 = &data_dht11;
    };

    keypad_pins {
        compatible = "gpio-keys";
        data_dht11: data_dht11 {
            gpios = <&gpio1 2 (GPIO_ACTIVE_HIGH | GPIO_PULL_UP)>;
        };
    };
};
